# Keil uVision project Project.uvproj, settings and files
target STM32303E_EVAL (ARM-ADS)
  device: STM32F303VE STMicroelectronics
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CLOCK(72000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32303E_EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F303xE,USE_STM32303E_EVAL,
  c misc: --C99
  c include: ..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F3xx\Include;..\..\..\..\..\..\Drivers\STM32F3xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\STM32303E_EVAL;..\..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\..\Utilities\Log;..\..\..\..\..\..\Utilities\CPU;..\..\..\..\..\..\Middlewares\Third_Party\FatFs\src;..\..\..\..\..\..\Middlewares\Third_Party\FatFs\src\drivers
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: main.c stm32f3xx_it.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32303E_EVAL
    ../../../../../../Drivers/BSP/STM32303E_EVAL/: stm32303e_eval.c stm32303e_eval_sd.c
  group Drivers/CMSIS
    ../Src/: system_stm32f3xx.c
  group Drivers/STM32F3xx_HAL_Driver
    ../../../../../../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal.c stm32f3xx_hal_cortex.c stm32f3xx_hal_dma.c stm32f3xx_hal_gpio.c stm32f3xx_hal_i2c.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_spi.c stm32f3xx_hal_uart.c stm32f3xx_hal_uart_ex.c
  group Example/MDK-ARM
    ./: startup_stm32f303xe.s
  group Middlewares/FatFs/Core
    ../../../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Middlewares/FatFs/Drivers
    ../../../../../../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
  group Middlewares/FatFs/Options
    ../../../../../../Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
