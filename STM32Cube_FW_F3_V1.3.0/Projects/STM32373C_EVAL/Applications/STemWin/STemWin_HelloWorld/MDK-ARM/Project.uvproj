# Keil uVision project Project.uvproj, settings and files
target STM32373C_EVAL (ARM-ADS)
  device: STM32F373VC STMicroelectronics
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32373C_EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32F373xC,USE_STM32373C_EVAL,
  c misc: --C99
  c include: ..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F3xx\Include;..\..\..\..\..\..\Drivers\STM32F3xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\STM32373C_EVAL;..\..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\..\Drivers\BSP\Components;..\..\..\..\..\..\Middlewares\ST\STemWin\inc;..\..\..\..\..\..\Utilities;..\..\..\..\..\..\Utilities\Fonts
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32f373xc.s
  group Application/User
    ../Src/: BASIC_HelloWorld.c main.c stm32f3xx_it.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components/hx8347g
    ../../../../../../Drivers/BSP/Components/hx8347g/: hx8347g.c
  group Drivers/BSP/Components/ili9328
    ../../../../../../Drivers/BSP/Components/ili9328/: ili9328.c
  group Drivers/BSP/STM32373C_EVAL
    ../../../../../../Drivers/BSP/STM32373C_EVAL/: stm32373c_eval.c
  group Drivers/CMSIS
    ../Src/: system_stm32f3xx.c
  group Drivers/STM32F3xx_HAL_Driver
    ../../../../../../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal.c stm32f3xx_hal_cortex.c stm32f3xx_hal_dma.c stm32f3xx_hal_gpio.c stm32f3xx_hal_rcc.c stm32f3xx_hal_spi.c stm32f3xx_hal_uart.c stm32f3xx_hal_uart_ex.c stm32f3xx_hal_rcc_ex.c
  group Middlewares/STemWin/Config
    ../Src/: GUIConf_stm32373c_eval.c LCDConf_stm32373c_eval.c
  group Middlewares/STemWin/Lib
    ../../../../../../Middlewares/ST/STemWin/Lib/: STemWin524b_CM4_Keil.lib
  group Middlewares/STemWin/OS
    ../../../../../../Middlewares/ST/STemWin/OS/: GUI_X.c
