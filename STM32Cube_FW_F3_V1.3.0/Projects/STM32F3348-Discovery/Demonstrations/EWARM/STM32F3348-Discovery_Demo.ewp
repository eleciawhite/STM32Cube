# IAR project STM32F3348-Discovery_Demo.ewp, settings and files
configuration STM32F3348-Discovery_Demo (ARM, debug)
  General.OGChipSelectEditMenu: STM32F334x8 ST STM32F334x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F334x8; USE_STM32F3348_DISCO
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\Drivers\CMSIS\Device\ST\STM32F3xx\Include; ..\..\..\..\Drivers\STM32F3xx_HAL_Driver\Inc; ..\..\..\..\Drivers\BSP\STM32F3348-Discovery; ..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\Utilities\Log; ..\..\..\..\Utilities\CPU
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32F3348-Discovery_Demo.hex
  ILINK.IlinkOutputFile: STM32F3348-Discovery_Demo.out
  ILINK.IlinkIcfFile: stm32f334x8_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Demonstration/EWARM
    ./: startup_stm32f334x8.s
  group Demonstration/User
    ../Src/: main.c stm32f3xx_it.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32F3348-Discovery
    ../../../../Drivers/BSP/STM32F3348-Discovery/: stm32f3348_discovery.c
  group Drivers/CMSIS
    ../Src/: system_stm32f3xx.c
  group Drivers/STM32F3xx_HAL_Driver
    ../../../../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal.c stm32f3xx_hal_adc.c stm32f3xx_hal_adc_ex.c stm32f3xx_hal_can.c stm32f3xx_hal_comp.c stm32f3xx_hal_cortex.c stm32f3xx_hal_crc.c stm32f3xx_hal_crc_ex.c stm32f3xx_hal_dac.c stm32f3xx_hal_dac_ex.c stm32f3xx_hal_dma.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_hrtim.c stm32f3xx_hal_i2c.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_iwdg.c stm32f3xx_hal_opamp.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_rtc.c stm32f3xx_hal_rtc_ex.c stm32f3xx_hal_spi.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_usart.c stm32f3xx_hal_wwdg.c
