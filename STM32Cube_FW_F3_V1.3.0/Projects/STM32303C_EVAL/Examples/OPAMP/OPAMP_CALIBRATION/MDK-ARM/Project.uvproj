# Keil uVision project Project.uvproj, settings and files
target STM32303C_EVAL (ARM-ADS)
  device: STM32F303VC STMicroelectronics
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) IRAM2(0x10000000,0x2000) CPUTYPE("Cortex-M4") FPU2 CLOCK(72000000) ELITTLE
  output: STM32303C_EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F303xC,USE_STM32303C_EVAL,
  c misc: --C99
  c include: ..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F3xx\Include;..\..\..\..\..\..\Drivers\STM32F3xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\STM32303C_EVAL;..\..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\..\Utilities\Log;..\..\..\..\..\..\Utilities\CPU
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x2000
  link misc: --diag_suppress=L6329
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32303C_EVAL
    ../../../../../../Drivers/BSP/STM32303C_EVAL/: stm32303c_eval.c
  group Drivers/CMSIS
    ../Src/: system_stm32f3xx.c
  group Drivers/STM32F3xx_HAL_Driver
    ../../../../../../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal.c stm32f3xx_hal_cortex.c stm32f3xx_hal_dac.c stm32f3xx_hal_dac_ex.c stm32f3xx_hal_dma.c stm32f3xx_hal_flash.c stm32f3xx_hal_gpio.c stm32f3xx_hal_i2c.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_opamp.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_rtc_ex.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_uart.c stm32f3xx_hal_uart_ex.c
  group Example/MDK-ARM
    ./: startup_stm32f303xc.s
  group Example/User
    ../Src/: main.c stm32f3xx_hal_msp.c stm32f3xx_it.c
