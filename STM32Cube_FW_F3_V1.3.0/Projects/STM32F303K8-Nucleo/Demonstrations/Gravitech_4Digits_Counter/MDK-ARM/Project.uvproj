# Keil uVision project Project.uvproj, settings and files
target STM32F303K8_NUCLEO (ARM-ADS)
  device: STM32F303K8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32F303K8_NUCLEO
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32F303x8,USE_STM32F3XX_NUCLEO_32,USE_HAL_DRIVER
  c misc: --C99
  c include: ..\Inc;..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F3xx\Include;..\..\..\..\..\Drivers\STM32F3xx_HAL_Driver\Inc;..\..\..\..\..\Drivers\BSP\STM32F3xx_Nucleo_32
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x3000
  memory RVCT10: RAM 0x10000000 size 0x1000
  link misc: --diag_suppress=L6329
  group Doc
    ../: readme.txt
  group Drivers/CMSIS
    ../Src/: system_stm32f3xx.c
  group Demo/MDK-ARM
    ./: startup_stm32f303x8.s
  group Drivers/STM32F3xx_HAL_Driver
    ../../../../../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal_rcc.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_cortex.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal.c stm32f3xx_hal_i2c.c stm32f3xx_hal_dma.c
  group Drivers/BSP/STM32F3xx_Nucleo_32
    ../../../../../Drivers/BSP/STM32F3xx_Nucleo_32/: stm32f3xx_nucleo_32.c
  group Demo/User
    ../Src/: stm32f3xx_it.c main.c
